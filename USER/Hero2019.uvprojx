# Keil uVision project Hero2019.uvprojx, settings and files
target Hero_2019 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CAN +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --C99
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\BSP;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FreeRTOSTask;..\IMU;..\Task;..\App;..\AHRS;..\DSP\Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group BSP
    ../BSP/: BasicPeripherals.c RemotDbus.c FrictionMoterPWM.c MotorCAN.c stmflash.c adc.c buzzer.c exit_init.c flash.c spi.c timer.c power_ctrl.c usart6.c
  group system
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f427_437xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_flash.c stm32f4xx_iwdg.c stm32f4xx_exti.c stm32f4xx_adc.c
  group FreeRTOSPortable
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group FreeRTOSCore
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group App
    ../App/: calibrate_task.c detect_task.c INS_task.c pid.c start_task.c user_lib.c chassis_behaviour.c chassis_task.c circular_buffer.c Referee_DispatchTask.c Tongs_Control_Task.c Key.c small_wheel_control_task.c electromagnetic_valve_task.c Steering_gear_control_task.c
  group AHRS
    ../AHRS/: AHRS_middleware.c ist8310driver.c ist8310driver_middleware.c mpu6500driver.c mpu6500driver_middleware.c AHRS.lib
  group DSP
    ../DSP/: arm_cortexM4lf_math.lib
